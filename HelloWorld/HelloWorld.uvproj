# Keil uVision project HelloWorld.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HelloWorld
  c flags: Optim=1
  c define: DEBUG_0
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s system_LPC17xx.c uart_polling.c main.c uart_polling.h
    ../src/: HAL.c heap.c heap.h memory.c memory.h process.c process.h process_queue.c process_queue.h rtx.h usr_proc.c printf.c printf.h
